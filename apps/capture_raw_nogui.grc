<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>capture_raw_nogui</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fc</value></param>
<param><key>label</key><value>fc</value></param>
<param><key>value</key><value>943.6e6</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>f</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>shiftoff</value></param>
<param><key>label</key><value>shiftoff</value></param>
<param><key>value</key><value>400e3</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>o</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ppm</value></param>
<param><key>label</key><value>ppm</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>short_id</key><value>p</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from math import pi</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>gain</value></param>
<param><key>value</key><value>30</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>g</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>samp_rate</value></param>
<param><key>value</key><value>2000000.052982</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>s</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value></value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>freq0</key><value>fc-shiftoff</value></param>
<param><key>corr0</key><value>ppm</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>250e3+abs(shiftoff)</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/tmp/gsm_raw</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
